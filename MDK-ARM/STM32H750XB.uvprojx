# Keil uVision project STM32H750XB.uvprojx, settings and files
target STM32H750XB (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: STM32H750XB +hex
  c flags: Optim=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,STM32H750xx
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;..\Application;..\Middlewares\LVGL\src;..\Middlewares\LVGL;..\Middlewares\LVGL\lv_demo_stress;../Middlewares/Third_Party/FatFs/src;../FATFS/Target;../FATFS/App;..\Middlewares\Malloc;../Middlewares/Third_Party/RealThread_RTOS/include/;../Middlewares/Third_Party/RealThread_RTOS/bsp/_template/cubemx_config;..\Middlewares\LVGL\src\hal;..\Middlewares\LVGL\src\core;..\Middlewares\Third_Party\LwIP\src\netif;..\LWIP\Target;..\LWIP\App;..\Middlewares\Third_Party\LwIP\src\api;..\Middlewares\Third_Party\LwIP\src\include;..\Middlewares\Third_Party\LwIP\system;..\Drivers\BSP\Components\lan8742;..\Middlewares\Third_Party\LwIP\src\include\lwip
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x90000000 size 0x800000
  memory RVCT6: RAM 0xc0000000 size 0x2000000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\ART-PI.sct
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User/Core
    ../Application/: w25qxx.c __stdlib_surpport__.c
    ../Core/Src/: main.c gpio.c dma.c dma2d.c fmc.c ltdc.c quadspi.c sai.c sdmmc.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_exti.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sdram.c stm32h7xx_hal_qspi.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c
  group Driver_in_exflash
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_dma2d.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group UserApp
    ../Application/: gt9147.c ctiic.c MusicDecode.c
  group Lvgl_exmple
    ../Middlewares/LVGL/demo/benchmark/assets/: img_benchmark_cogwheel_alpha16.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_chroma_keyed.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_rgb.c img_benchmark_cogwheel_rgb565a8.c lv_font_bechmark_montserrat_12_compr_az.c.c lv_font_bechmark_montserrat_16_compr_az.c.c lv_font_bechmark_montserrat_28_compr_az.c.c
    ../Middlewares/LVGL/demo/benchmark/: lv_demo_benchmark.c
    ../Middlewares/LVGL/demo/music/assets/: img_lv_demo_music_btn_corner_large.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_loop_large.c img_lv_demo_music_btn_next.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_btn_pause.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_btn_play.c img_lv_demo_music_btn_play_large.c img_lv_demo_music_btn_prev.c img_lv_demo_music_btn_prev_large.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_corner_left.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_corner_right.c img_lv_demo_music_corner_right_large.c img_lv_demo_music_cover_1.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_cover_2.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_cover_3.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_icon_2.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_icon_3.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_icon_4.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_list_border.c img_lv_demo_music_list_border_large.c img_lv_demo_music_logo.c img_lv_demo_music_slider_knob.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_wave_top.c img_lv_demo_music_wave_top_large.c
    ../Middlewares/LVGL/demo/music/: lv_demo_music.c lv_demo_music_list.c lv_demo_music_main.c
    ../Middlewares/LVGL/demo/widgets/: lv_demo_widgets.c
    ../Middlewares/LVGL/demo/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
  group Lvgl_core
    ../Middlewares/LVGL/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group Lvgl_draw
    ../Middlewares/LVGL/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Middlewares/LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
  group Lvgl_font
    ../Middlewares/LVGL/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group Lvgl_gpu
    ../Middlewares/LVGL/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
  group Lvgl_hal
    ../Middlewares/LVGL/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group Lvgl_misc
    ../Middlewares/LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_malloc_builtin.c lv_math.c lv_mem.c lv_memcpy_builtin.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group Lvgl_widgets
    ../Middlewares/LVGL/src/widgets/animimg/: lv_animimg.c
    ../Middlewares/LVGL/src/widgets/arc/: lv_arc.c
    ../Middlewares/LVGL/src/widgets/bar/: lv_bar.c
    ../Middlewares/LVGL/src/widgets/btn/: lv_btn.c
    ../Middlewares/LVGL/src/widgets/btnmatrix/: lv_btnmatrix.c
    ../Middlewares/LVGL/src/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Middlewares/LVGL/src/widgets/canvas/: lv_canvas.c
    ../Middlewares/LVGL/src/widgets/chart/: lv_chart.c
    ../Middlewares/LVGL/src/widgets/checkbox/: lv_checkbox.c
    ../Middlewares/LVGL/src/widgets/colorwheel/: lv_colorwheel.c
    ../Middlewares/LVGL/src/widgets/dropdown/: lv_dropdown.c
    ../Middlewares/LVGL/src/widgets/img/: lv_img.c
    ../Middlewares/LVGL/src/widgets/imgbtn/: lv_imgbtn.c
    ../Middlewares/LVGL/src/widgets/keyboard/: lv_keyboard.c
    ../Middlewares/LVGL/src/widgets/label/: lv_label.c
    ../Middlewares/LVGL/src/widgets/led/: lv_led.c
    ../Middlewares/LVGL/src/widgets/line/: lv_line.c
    ../Middlewares/LVGL/src/widgets/list/: lv_list.c
    ../Middlewares/LVGL/src/widgets/menu/: lv_menu.c
    ../Middlewares/LVGL/src/widgets/meter/: lv_meter.c
    ../Middlewares/LVGL/src/widgets/msgbox/: lv_msgbox.c
    ../Middlewares/LVGL/src/widgets/objx_templ/: lv_objx_templ.c
    ../Middlewares/LVGL/src/widgets/roller/: lv_roller.c
    ../Middlewares/LVGL/src/widgets/slider/: lv_slider.c
    ../Middlewares/LVGL/src/widgets/span/: lv_span.c
    ../Middlewares/LVGL/src/widgets/spinbox/: lv_spinbox.c
    ../Middlewares/LVGL/src/widgets/spinner/: lv_spinner.c
    ../Middlewares/LVGL/src/widgets/switch/: lv_switch.c
    ../Middlewares/LVGL/src/widgets/table/: lv_table.c
    ../Middlewares/LVGL/src/widgets/tabview/: lv_tabview.c
    ../Middlewares/LVGL/src/widgets/textarea/: lv_textarea.c
    ../Middlewares/LVGL/src/widgets/tileview/: lv_tileview.c
    ../Middlewares/LVGL/src/widgets/win/: lv_win.c
  group Lvgl_themes
    ../Middlewares/LVGL/src/themes/basic/: lv_theme_basic.c
    ../Middlewares/LVGL/src/themes/default/: lv_theme_default.c
    ../Middlewares/LVGL/src/themes/mono/: lv_theme_mono.c
  group Lvgl_layout
    ../Middlewares/LVGL/src/layouts/grid/: lv_grid.c
    ../Middlewares/LVGL/src/layouts/flex/: lv_flex.c
  group Lvgl_lib
    ../Middlewares/LVGL/src/libs/bmp/: lv_bmp.c
    ../Middlewares/LVGL/src/libs/ffmpeg/: lv_ffmpeg.c
    ../Middlewares/LVGL/src/libs/freetype/: lv_freetype.c
    ../Middlewares/LVGL/src/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../Middlewares/LVGL/src/libs/gif/: gifdec.c lv_gif.c
    ../Middlewares/LVGL/src/libs/png/: lodepng.c lv_png.c
    ../Middlewares/LVGL/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Middlewares/LVGL/src/libs/sjpg/: lv_sjpg.c tjpgd.c
  group LvglBsp
    ../Middlewares/LVGL/: LvglBsp.c MyGuiDemo.c about.c background.c delet.c image.c mail.c pos.c ExternFont.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c ffsystem.c ffunicode.c
  group Middlewares/RT-Thread/RTOS/kernel
    ../Middlewares/Third_Party/RealThread_RTOS/libcpu/arm/cortex-m7/: context_rvds.S cpuport.c cpu_cache.c
    ../Middlewares/Third_Party/RealThread_RTOS/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
    ../Middlewares/Third_Party/RealThread_RTOS/bsp/_template/cubemx_config/: board.c
  group Lwip_Adaptor
    ../LWIP/App/: lwip.c
    ../LWIP/Target/: ethernetif.c
    ../Drivers/BSP/Components/lan8742/: lan8742.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Lwip_Source
    ../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Middlewares/Third_Party/LwIP/src/core/: altcp.c altcp_alloc.c def.c dns.c inet_chksum.c init.c ip.c netif.c mem.c memp.c pbuf.c stats.c raw.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c
software components: CMSIS:CORE 5.6.0, Compiler:Event Recorder 1.5.1, Compiler:I/O:STDOUT 1.2.0
